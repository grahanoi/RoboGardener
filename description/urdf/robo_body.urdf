Commit message: rename urdf file

File: description/urdf/robo_body.urdf (robot description, URDF)
Before this commit: robot body, 1 links, 0 joints
Links:
- link base_link: geometry visual box size=0.5 0.5 0.2
